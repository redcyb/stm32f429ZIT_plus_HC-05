<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\disco_bt2.ewp</path>
  </project>
  <batchBuild />
</workspace>
